Properties of the parts of a building model (IFC4)

# File
Description: Trendliner Kontrast Sib. Lärche elegant gehobelt 27 x 96 4m, File generated by Heinze, ViewDefinition[CoordinationView]
File name: file.ifc
Time: 2025-01-31T12:19:27+0100
Author: Heinze GmbH, kundenservice@heinze.de
Organization: Heinze GmbH, Bremer Weg 184, 29223 Celle, Tel. +49 (0)5141 5055, https://www.heinze.de/
Written by: N/A
Made in: Heinze
Authorization: N/A

# IfcProject, Ladenburger Project
Description: Ladenburger GmbH default project for Heinze

# IfcBuilding, Ladenburger Building
Description: Ladenburger GmbH default building for Heinze

# IfcBuildingStorey, Default Storey
In: Ladenburger Building
Description: Default storey

# IfcSpace, Default Space
In: Default Storey
Description: Default space for placing elements

# IfcBuildingElementProxy, Trendliner Kontrast Sib. Lärche elegant gehobelt 27 x 96 4m
In: Default Space
Description: Im verarbeiteten Zustand sieht das Fassadenprofil wie eine klassische Rhomboidleiste mit schwarzer Unterspannbahn aus. Die abgerundeten Schrägkanten ergeben eine elegante Fugenbildung. Durch die Kontrastfeder entsteht eine klare Struktur, die den linearen Charakter des Gebäudes betont. Verschiedene Profilbreiten und Oberflächen stehen für unterschiedliche Optiken zur Auswahl.
Pset_BIMSITE - Farbton: beige, braun, farblos, grau, metallfarben, nach Hersteller-Farbkarte, orange; Oberfläche: gehobelt, unbehandelt; Werkstoff: Holz; Breite: 96; Länge: 4000; Stärke: 27; Art: Steckaußenschalung mit Nut und Feder; Holzart: Lärche, Sibirische Lärche; Holzsortierung: A-Sortierung, B-Sortierung; Kantenausführung: abgerundet
Pset_BIMsite_ProductCodes - Description: PropertySet with ProductCodes
Pset_BIMsite_Documents - DOCUMENT_USAGE_TYPE_DATASHEET 1: https://media.heinze.de/m2/88/62488/etc/83/47482783.pdf; DOCUMENT_USAGE_TYPE_DATASHEET 2: https://media.heinze.de/m2/88/62488/etc/88/42709688.pdf; DOCUMENT_USAGE_TYPE_DATASHEET 3: https://media.heinze.de/m2/88/62488/etc/79/47482779.pdf; DOCUMENT_USAGE_TYPE_DATASHEET 4: https://media.heinze.de/m2/88/62488/etc/87/42709687.pdf
Pset_BIMsite_Links - LINK_TYPE_PRODUCT_PAGE 1: https://www.ladenburger.de/index.php/de/fassaden-profilholz/kontrast-edition/trendliner-kontrast; LINK_TYPE_TOOL 2: https://ladenburger.de/konfigurator/
Pset_BIMsite_Categories - HEINZE_CATEGORY: Profilholz-Bretter
Pset_BIMsite_ManufacturerProperties - Deckmaß (mm): 74; Eigenschaften: durch das Nut und Feder Fassadenprofil kann auf UV-beständige Unterspannbahnen verzichtet werden; Farbton 1: UV-Plus, Sanddorn, Antikgrau, Kieselgrau, Naturgrau, Schiefergrau, Mokka, Altgrau (Metallic-Effekt); Oberflächenausbildung: 8 mögliche Farbtöne; Stk. pro Bund: 4; Stk. pro Paket: 168
